SRC_URI_append_sh4 = "\
    file://sh4_initscripts.patch \
"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
