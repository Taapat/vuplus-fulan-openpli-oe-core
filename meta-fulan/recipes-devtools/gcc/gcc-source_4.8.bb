require recipes-devtools/gcc/gcc-${PV}.inc
require gcc-source.inc

EXCLUDE_FROM_WORLD = "1"
