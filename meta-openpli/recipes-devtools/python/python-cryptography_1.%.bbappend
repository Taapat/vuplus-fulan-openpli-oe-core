PR = "r1"

FILES_${PN}-dbg += " \
    ${libdir}/python2.7/site-packages/*.egg-info \
    "
